.ic V(q_0_0_0) = 0V
.ic V(q_0_1_0) = 0V
.ic V(q_0_2_0) = 0V
.ic V(q_0_3_0) = 0V
.ic V(q_0_4_0) = 0V
.ic V(q_0_5_0) = 0.5V
.ic V(q_0_6_0) = 0.5V
.ic V(q_0_7_0) = 0V
.ic V(q_0_8_0) = 0.5V
.ic V(q_0_9_0) = 0.5V
.ic V(q_0_10_0) = 0.5V
.ic V(q_0_11_0) = 0.5V
.ic V(q_0_12_0) = 0V
.ic V(q_0_13_0) = 0V
.ic V(q_0_14_0) = 0.5V
.ic V(q_0_15_0) = 0V
.ic V(q_0_16_0) = 0V
.ic V(q_0_17_0) = 0V
.ic V(q_0_18_0) = 0.5V
.ic V(q_0_19_0) = 0V
.ic V(q_0_20_0) = 0V
.ic V(q_0_21_0) = 0V
.ic V(q_0_22_0) = 0V
.ic V(q_0_23_0) = 0V
.ic V(q_0_24_0) = 0.5V
.ic V(q_0_25_0) = 0.5V
.ic V(q_0_26_0) = 0V
.ic V(q_0_27_0) = 0.5V
.ic V(q_0_28_0) = 0V
.ic V(q_0_29_0) = 0.5V
.ic V(q_0_30_0) = 0.5V
.ic V(q_0_31_0) = 0V
.ic V(q_1_0_0) = 0V
.ic V(q_1_1_0) = 0V
.ic V(q_1_2_0) = 0.5V
.ic V(q_1_3_0) = 0V
.ic V(q_1_4_0) = 0.5V
.ic V(q_1_5_0) = 0V
.ic V(q_1_6_0) = 0V
.ic V(q_1_7_0) = 0.5V
.ic V(q_1_8_0) = 0.5V
.ic V(q_1_9_0) = 0.5V
.ic V(q_1_10_0) = 0.5V
.ic V(q_1_11_0) = 0V
.ic V(q_1_12_0) = 0V
.ic V(q_1_13_0) = 0V
.ic V(q_1_14_0) = 0V
.ic V(q_1_15_0) = 0V
.ic V(q_1_16_0) = 0.5V
.ic V(q_1_17_0) = 0V
.ic V(q_1_18_0) = 0.5V
.ic V(q_1_19_0) = 0V
.ic V(q_1_20_0) = 0.5V
.ic V(q_1_21_0) = 0V
.ic V(q_1_22_0) = 0.5V
.ic V(q_1_23_0) = 0.5V
.ic V(q_1_24_0) = 0V
.ic V(q_1_25_0) = 0V
.ic V(q_1_26_0) = 0.5V
.ic V(q_1_27_0) = 0.5V
.ic V(q_1_28_0) = 0.5V
.ic V(q_1_29_0) = 0.5V
.ic V(q_1_30_0) = 0V
.ic V(q_1_31_0) = 0.5V
.ic V(q_2_0_0) = 0.5V
.ic V(q_2_1_0) = 0.5V
.ic V(q_2_2_0) = 0.5V
.ic V(q_2_3_0) = 0.5V
.ic V(q_2_4_0) = 0V
.ic V(q_2_5_0) = 0V
.ic V(q_2_6_0) = 0.5V
.ic V(q_2_7_0) = 0.5V
.ic V(q_2_8_0) = 0V
.ic V(q_2_9_0) = 0V
.ic V(q_2_10_0) = 0V
.ic V(q_2_11_0) = 0.5V
.ic V(q_2_12_0) = 0.5V
.ic V(q_2_13_0) = 0.5V
.ic V(q_2_14_0) = 0.5V
.ic V(q_2_15_0) = 0.5V
.ic V(q_2_16_0) = 0.5V
.ic V(q_2_17_0) = 0V
.ic V(q_2_18_0) = 0.5V
.ic V(q_2_19_0) = 0V
.ic V(q_2_20_0) = 0V
.ic V(q_2_21_0) = 0V
.ic V(q_2_22_0) = 0V
.ic V(q_2_23_0) = 0V
.ic V(q_2_24_0) = 0V
.ic V(q_2_25_0) = 0.5V
.ic V(q_2_26_0) = 0V
.ic V(q_2_27_0) = 0.5V
.ic V(q_2_28_0) = 0V
.ic V(q_2_29_0) = 0.5V
.ic V(q_2_30_0) = 0.5V
.ic V(q_2_31_0) = 0.5V
.ic V(q_3_0_0) = 0V
.ic V(q_3_1_0) = 0.5V
.ic V(q_3_2_0) = 0V
.ic V(q_3_3_0) = 0.5V
.ic V(q_3_4_0) = 0V
.ic V(q_3_5_0) = 0V
.ic V(q_3_6_0) = 0V
.ic V(q_3_7_0) = 0V
.ic V(q_3_8_0) = 0V
.ic V(q_3_9_0) = 0V
.ic V(q_3_10_0) = 0V
.ic V(q_3_11_0) = 0.5V
.ic V(q_3_12_0) = 0V
.ic V(q_3_13_0) = 0V
.ic V(q_3_14_0) = 0V
.ic V(q_3_15_0) = 0V
.ic V(q_3_16_0) = 0V
.ic V(q_3_17_0) = 0.5V
.ic V(q_3_18_0) = 0V
.ic V(q_3_19_0) = 0.5V
.ic V(q_3_20_0) = 0V
.ic V(q_3_21_0) = 0.5V
.ic V(q_3_22_0) = 0.5V
.ic V(q_3_23_0) = 0V
.ic V(q_3_24_0) = 0V
.ic V(q_3_25_0) = 0V
.ic V(q_3_26_0) = 0.5V
.ic V(q_3_27_0) = 0V
.ic V(q_3_28_0) = 0V
.ic V(q_3_29_0) = 0.5V
.ic V(q_3_30_0) = 0V
.ic V(q_3_31_0) = 0V
.ic V(q_0_0_1) = 0V
.ic V(q_0_1_1) = 0V
.ic V(q_0_2_1) = 0.5V
.ic V(q_0_3_1) = 0V
.ic V(q_0_4_1) = 0.5V
.ic V(q_0_5_1) = 0.5V
.ic V(q_0_6_1) = 0V
.ic V(q_0_7_1) = 0.5V
.ic V(q_0_8_1) = 0V
.ic V(q_0_9_1) = 0V
.ic V(q_0_10_1) = 0.5V
.ic V(q_0_11_1) = 0V
.ic V(q_0_12_1) = 0.5V
.ic V(q_0_13_1) = 0V
.ic V(q_0_14_1) = 0.5V
.ic V(q_0_15_1) = 0V
.ic V(q_0_16_1) = 0.5V
.ic V(q_0_17_1) = 0.5V
.ic V(q_0_18_1) = 0.5V
.ic V(q_0_19_1) = 0V
.ic V(q_0_20_1) = 0.5V
.ic V(q_0_21_1) = 0.5V
.ic V(q_0_22_1) = 0.5V
.ic V(q_0_23_1) = 0V
.ic V(q_0_24_1) = 0.5V
.ic V(q_0_25_1) = 0.5V
.ic V(q_0_26_1) = 0V
.ic V(q_0_27_1) = 0.5V
.ic V(q_0_28_1) = 0.5V
.ic V(q_0_29_1) = 0V
.ic V(q_0_30_1) = 0.5V
.ic V(q_0_31_1) = 0.5V
.ic V(q_1_0_1) = 0V
.ic V(q_1_1_1) = 0V
.ic V(q_1_2_1) = 0.5V
.ic V(q_1_3_1) = 0V
.ic V(q_1_4_1) = 0.5V
.ic V(q_1_5_1) = 0V
.ic V(q_1_6_1) = 0V
.ic V(q_1_7_1) = 0.5V
.ic V(q_1_8_1) = 0V
.ic V(q_1_9_1) = 0.5V
.ic V(q_1_10_1) = 0.5V
.ic V(q_1_11_1) = 0V
.ic V(q_1_12_1) = 0V
.ic V(q_1_13_1) = 0.5V
.ic V(q_1_14_1) = 0V
.ic V(q_1_15_1) = 0V
.ic V(q_1_16_1) = 0V
.ic V(q_1_17_1) = 0.5V
.ic V(q_1_18_1) = 0.5V
.ic V(q_1_19_1) = 0.5V
.ic V(q_1_20_1) = 0V
.ic V(q_1_21_1) = 0V
.ic V(q_1_22_1) = 0V
.ic V(q_1_23_1) = 0V
.ic V(q_1_24_1) = 0V
.ic V(q_1_25_1) = 0.5V
.ic V(q_1_26_1) = 0V
.ic V(q_1_27_1) = 0.5V
.ic V(q_1_28_1) = 0.5V
.ic V(q_1_29_1) = 0V
.ic V(q_1_30_1) = 0.5V
.ic V(q_1_31_1) = 0.5V
.ic V(q_2_0_1) = 0V
.ic V(q_2_1_1) = 0.5V
.ic V(q_2_2_1) = 0V
.ic V(q_2_3_1) = 0V
.ic V(q_2_4_1) = 0.5V
.ic V(q_2_5_1) = 0V
.ic V(q_2_6_1) = 0V
.ic V(q_2_7_1) = 0.5V
.ic V(q_2_8_1) = 0.5V
.ic V(q_2_9_1) = 0.5V
.ic V(q_2_10_1) = 0V
.ic V(q_2_11_1) = 0.5V
.ic V(q_2_12_1) = 0V
.ic V(q_2_13_1) = 0.5V
.ic V(q_2_14_1) = 0.5V
.ic V(q_2_15_1) = 0.5V
.ic V(q_2_16_1) = 0V
.ic V(q_2_17_1) = 0.5V
.ic V(q_2_18_1) = 0V
.ic V(q_2_19_1) = 0V
.ic V(q_2_20_1) = 0V
.ic V(q_2_21_1) = 0.5V
.ic V(q_2_22_1) = 0.5V
.ic V(q_2_23_1) = 0V
.ic V(q_2_24_1) = 0.5V
.ic V(q_2_25_1) = 0V
.ic V(q_2_26_1) = 0.5V
.ic V(q_2_27_1) = 0.5V
.ic V(q_2_28_1) = 0.5V
.ic V(q_2_29_1) = 0V
.ic V(q_2_30_1) = 0.5V
.ic V(q_2_31_1) = 0.5V
.ic V(q_3_0_1) = 0V
.ic V(q_3_1_1) = 0.5V
.ic V(q_3_2_1) = 0.5V
.ic V(q_3_3_1) = 0.5V
.ic V(q_3_4_1) = 0V
.ic V(q_3_5_1) = 0.5V
.ic V(q_3_6_1) = 0V
.ic V(q_3_7_1) = 0V
.ic V(q_3_8_1) = 0V
.ic V(q_3_9_1) = 0.5V
.ic V(q_3_10_1) = 0V
.ic V(q_3_11_1) = 0.5V
.ic V(q_3_12_1) = 0.5V
.ic V(q_3_13_1) = 0V
.ic V(q_3_14_1) = 0V
.ic V(q_3_15_1) = 0V
.ic V(q_3_16_1) = 0V
.ic V(q_3_17_1) = 0V
.ic V(q_3_18_1) = 0V
.ic V(q_3_19_1) = 0V
.ic V(q_3_20_1) = 0V
.ic V(q_3_21_1) = 0V
.ic V(q_3_22_1) = 0V
.ic V(q_3_23_1) = 0V
.ic V(q_3_24_1) = 0V
.ic V(q_3_25_1) = 0V
.ic V(q_3_26_1) = 0.5V
.ic V(q_3_27_1) = 0V
.ic V(q_3_28_1) = 0.5V
.ic V(q_3_29_1) = 0V
.ic V(q_3_30_1) = 0.5V
.ic V(q_3_31_1) = 0V
.ic V(q_0_0_2) = 0.5V
.ic V(q_0_1_2) = 0.5V
.ic V(q_0_2_2) = 0.5V
.ic V(q_0_3_2) = 0.5V
.ic V(q_0_4_2) = 0V
.ic V(q_0_5_2) = 0V
.ic V(q_0_6_2) = 0.5V
.ic V(q_0_7_2) = 0.5V
.ic V(q_0_8_2) = 0.5V
.ic V(q_0_9_2) = 0V
.ic V(q_0_10_2) = 0V
.ic V(q_0_11_2) = 0V
.ic V(q_0_12_2) = 0.5V
.ic V(q_0_13_2) = 0.5V
.ic V(q_0_14_2) = 0.5V
.ic V(q_0_15_2) = 0.5V
.ic V(q_0_16_2) = 0.5V
.ic V(q_0_17_2) = 0V
.ic V(q_0_18_2) = 0V
.ic V(q_0_19_2) = 0.5V
.ic V(q_0_20_2) = 0V
.ic V(q_0_21_2) = 0V
.ic V(q_0_22_2) = 0V
.ic V(q_0_23_2) = 0.5V
.ic V(q_0_24_2) = 0V
.ic V(q_0_25_2) = 0V
.ic V(q_0_26_2) = 0.5V
.ic V(q_0_27_2) = 0V
.ic V(q_0_28_2) = 0.5V
.ic V(q_0_29_2) = 0.5V
.ic V(q_0_30_2) = 0V
.ic V(q_0_31_2) = 0V
.ic V(q_1_0_2) = 0.5V
.ic V(q_1_1_2) = 0.5V
.ic V(q_1_2_2) = 0.5V
.ic V(q_1_3_2) = 0.5V
.ic V(q_1_4_2) = 0.5V
.ic V(q_1_5_2) = 0V
.ic V(q_1_6_2) = 0.5V
.ic V(q_1_7_2) = 0.5V
.ic V(q_1_8_2) = 0.5V
.ic V(q_1_9_2) = 0V
.ic V(q_1_10_2) = 0.5V
.ic V(q_1_11_2) = 0.5V
.ic V(q_1_12_2) = 0.5V
.ic V(q_1_13_2) = 0V
.ic V(q_1_14_2) = 0V
.ic V(q_1_15_2) = 0V
.ic V(q_1_16_2) = 0V
.ic V(q_1_17_2) = 0.5V
.ic V(q_1_18_2) = 0V
.ic V(q_1_19_2) = 0V
.ic V(q_1_20_2) = 0V
.ic V(q_1_21_2) = 0.5V
.ic V(q_1_22_2) = 0.5V
.ic V(q_1_23_2) = 0.5V
.ic V(q_1_24_2) = 0.5V
.ic V(q_1_25_2) = 0.5V
.ic V(q_1_26_2) = 0V
.ic V(q_1_27_2) = 0V
.ic V(q_1_28_2) = 0.5V
.ic V(q_1_29_2) = 0V
.ic V(q_1_30_2) = 0.5V
.ic V(q_1_31_2) = 0.5V
.ic V(q_2_0_2) = 0.5V
.ic V(q_2_1_2) = 0V
.ic V(q_2_2_2) = 0V
.ic V(q_2_3_2) = 0V
.ic V(q_2_4_2) = 0.5V
.ic V(q_2_5_2) = 0V
.ic V(q_2_6_2) = 0.5V
.ic V(q_2_7_2) = 0.5V
.ic V(q_2_8_2) = 0.5V
.ic V(q_2_9_2) = 0V
.ic V(q_2_10_2) = 0.5V
.ic V(q_2_11_2) = 0V
.ic V(q_2_12_2) = 0V
.ic V(q_2_13_2) = 0V
.ic V(q_2_14_2) = 0.5V
.ic V(q_2_15_2) = 0V
.ic V(q_2_16_2) = 0.5V
.ic V(q_2_17_2) = 0.5V
.ic V(q_2_18_2) = 0V
.ic V(q_2_19_2) = 0.5V
.ic V(q_2_20_2) = 0V
.ic V(q_2_21_2) = 0.5V
.ic V(q_2_22_2) = 0.5V
.ic V(q_2_23_2) = 0.5V
.ic V(q_2_24_2) = 0.5V
.ic V(q_2_25_2) = 0V
.ic V(q_2_26_2) = 0.5V
.ic V(q_2_27_2) = 0V
.ic V(q_2_28_2) = 0V
.ic V(q_2_29_2) = 0V
.ic V(q_2_30_2) = 0.5V
.ic V(q_2_31_2) = 0V
.ic V(q_3_0_2) = 0V
.ic V(q_3_1_2) = 0V
.ic V(q_3_2_2) = 0.5V
.ic V(q_3_3_2) = 0.5V
.ic V(q_3_4_2) = 0.5V
.ic V(q_3_5_2) = 0.5V
.ic V(q_3_6_2) = 0.5V
.ic V(q_3_7_2) = 0V
.ic V(q_3_8_2) = 0V
.ic V(q_3_9_2) = 0V
.ic V(q_3_10_2) = 0.5V
.ic V(q_3_11_2) = 0.5V
.ic V(q_3_12_2) = 0.5V
.ic V(q_3_13_2) = 0V
.ic V(q_3_14_2) = 0V
.ic V(q_3_15_2) = 0.5V
.ic V(q_3_16_2) = 0V
.ic V(q_3_17_2) = 0V
.ic V(q_3_18_2) = 0V
.ic V(q_3_19_2) = 0V
.ic V(q_3_20_2) = 0.5V
.ic V(q_3_21_2) = 0V
.ic V(q_3_22_2) = 0V
.ic V(q_3_23_2) = 0V
.ic V(q_3_24_2) = 0V
.ic V(q_3_25_2) = 0V
.ic V(q_3_26_2) = 0V
.ic V(q_3_27_2) = 0V
.ic V(q_3_28_2) = 0.5V
.ic V(q_3_29_2) = 0.5V
.ic V(q_3_30_2) = 0.5V
.ic V(q_3_31_2) = 0V
.ic V(q_0_0_3) = 0.5V
.ic V(q_0_1_3) = 0V
.ic V(q_0_2_3) = 0.5V
.ic V(q_0_3_3) = 0.5V
.ic V(q_0_4_3) = 0.5V
.ic V(q_0_5_3) = 0.5V
.ic V(q_0_6_3) = 0.5V
.ic V(q_0_7_3) = 0.5V
.ic V(q_0_8_3) = 0V
.ic V(q_0_9_3) = 0V
.ic V(q_0_10_3) = 0.5V
.ic V(q_0_11_3) = 0.5V
.ic V(q_0_12_3) = 0.5V
.ic V(q_0_13_3) = 0.5V
.ic V(q_0_14_3) = 0.5V
.ic V(q_0_15_3) = 0V
.ic V(q_0_16_3) = 0V
.ic V(q_0_17_3) = 0V
.ic V(q_0_18_3) = 0.5V
.ic V(q_0_19_3) = 0V
.ic V(q_0_20_3) = 0V
.ic V(q_0_21_3) = 0V
.ic V(q_0_22_3) = 0.5V
.ic V(q_0_23_3) = 0V
.ic V(q_0_24_3) = 0V
.ic V(q_0_25_3) = 0V
.ic V(q_0_26_3) = 0.5V
.ic V(q_0_27_3) = 0V
.ic V(q_0_28_3) = 0.5V
.ic V(q_0_29_3) = 0V
.ic V(q_0_30_3) = 0V
.ic V(q_0_31_3) = 0V
.ic V(q_1_0_3) = 0.5V
.ic V(q_1_1_3) = 0.5V
.ic V(q_1_2_3) = 0.5V
.ic V(q_1_3_3) = 0V
.ic V(q_1_4_3) = 0.5V
.ic V(q_1_5_3) = 0.5V
.ic V(q_1_6_3) = 0V
.ic V(q_1_7_3) = 0.5V
.ic V(q_1_8_3) = 0V
.ic V(q_1_9_3) = 0V
.ic V(q_1_10_3) = 0V
.ic V(q_1_11_3) = 0.5V
.ic V(q_1_12_3) = 0.5V
.ic V(q_1_13_3) = 0V
.ic V(q_1_14_3) = 0.5V
.ic V(q_1_15_3) = 0V
.ic V(q_1_16_3) = 0.5V
.ic V(q_1_17_3) = 0.5V
.ic V(q_1_18_3) = 0.5V
.ic V(q_1_19_3) = 0.5V
.ic V(q_1_20_3) = 0.5V
.ic V(q_1_21_3) = 0V
.ic V(q_1_22_3) = 0.5V
.ic V(q_1_23_3) = 0V
.ic V(q_1_24_3) = 0V
.ic V(q_1_25_3) = 0V
.ic V(q_1_26_3) = 0.5V
.ic V(q_1_27_3) = 0.5V
.ic V(q_1_28_3) = 0V
.ic V(q_1_29_3) = 0.5V
.ic V(q_1_30_3) = 0.5V
.ic V(q_1_31_3) = 0.5V
.ic V(q_2_0_3) = 0.5V
.ic V(q_2_1_3) = 0.5V
.ic V(q_2_2_3) = 0V
.ic V(q_2_3_3) = 0.5V
.ic V(q_2_4_3) = 0.5V
.ic V(q_2_5_3) = 0.5V
.ic V(q_2_6_3) = 0.5V
.ic V(q_2_7_3) = 0V
.ic V(q_2_8_3) = 0V
.ic V(q_2_9_3) = 0.5V
.ic V(q_2_10_3) = 0.5V
.ic V(q_2_11_3) = 0.5V
.ic V(q_2_12_3) = 0V
.ic V(q_2_13_3) = 0.5V
.ic V(q_2_14_3) = 0.5V
.ic V(q_2_15_3) = 0.5V
.ic V(q_2_16_3) = 0.5V
.ic V(q_2_17_3) = 0V
.ic V(q_2_18_3) = 0.5V
.ic V(q_2_19_3) = 0.5V
.ic V(q_2_20_3) = 0V
.ic V(q_2_21_3) = 0V
.ic V(q_2_22_3) = 0.5V
.ic V(q_2_23_3) = 0V
.ic V(q_2_24_3) = 0.5V
.ic V(q_2_25_3) = 0V
.ic V(q_2_26_3) = 0.5V
.ic V(q_2_27_3) = 0V
.ic V(q_2_28_3) = 0.5V
.ic V(q_2_29_3) = 0V
.ic V(q_2_30_3) = 0.5V
.ic V(q_2_31_3) = 0.5V
.ic V(q_3_0_3) = 0V
.ic V(q_3_1_3) = 0.5V
.ic V(q_3_2_3) = 0V
.ic V(q_3_3_3) = 0V
.ic V(q_3_4_3) = 0V
.ic V(q_3_5_3) = 0V
.ic V(q_3_6_3) = 0V
.ic V(q_3_7_3) = 0V
.ic V(q_3_8_3) = 0.5V
.ic V(q_3_9_3) = 0V
.ic V(q_3_10_3) = 0.5V
.ic V(q_3_11_3) = 0.5V
.ic V(q_3_12_3) = 0.5V
.ic V(q_3_13_3) = 0V
.ic V(q_3_14_3) = 0.5V
.ic V(q_3_15_3) = 0.5V
.ic V(q_3_16_3) = 0.5V
.ic V(q_3_17_3) = 0V
.ic V(q_3_18_3) = 0.5V
.ic V(q_3_19_3) = 0V
.ic V(q_3_20_3) = 0.5V
.ic V(q_3_21_3) = 0.5V
.ic V(q_3_22_3) = 0.5V
.ic V(q_3_23_3) = 0V
.ic V(q_3_24_3) = 0V
.ic V(q_3_25_3) = 0V
.ic V(q_3_26_3) = 0V
.ic V(q_3_27_3) = 0V
.ic V(q_3_28_3) = 0.5V
.ic V(q_3_29_3) = 0V
.ic V(q_3_30_3) = 0V
.ic V(q_3_31_3) = 0V
.ic V(qb_0_0_0) = 0.5V
.ic V(qb_0_1_0) = 0.5V
.ic V(qb_0_2_0) = 0.5V
.ic V(qb_0_3_0) = 0.5V
.ic V(qb_0_4_0) = 0.5V
.ic V(qb_0_5_0) = 0V
.ic V(qb_0_6_0) = 0V
.ic V(qb_0_7_0) = 0.5V
.ic V(qb_0_8_0) = 0V
.ic V(qb_0_9_0) = 0V
.ic V(qb_0_10_0) = 0V
.ic V(qb_0_11_0) = 0V
.ic V(qb_0_12_0) = 0.5V
.ic V(qb_0_13_0) = 0.5V
.ic V(qb_0_14_0) = 0V
.ic V(qb_0_15_0) = 0.5V
.ic V(qb_0_16_0) = 0.5V
.ic V(qb_0_17_0) = 0.5V
.ic V(qb_0_18_0) = 0V
.ic V(qb_0_19_0) = 0.5V
.ic V(qb_0_20_0) = 0.5V
.ic V(qb_0_21_0) = 0.5V
.ic V(qb_0_22_0) = 0.5V
.ic V(qb_0_23_0) = 0.5V
.ic V(qb_0_24_0) = 0V
.ic V(qb_0_25_0) = 0V
.ic V(qb_0_26_0) = 0.5V
.ic V(qb_0_27_0) = 0V
.ic V(qb_0_28_0) = 0.5V
.ic V(qb_0_29_0) = 0V
.ic V(qb_0_30_0) = 0V
.ic V(qb_0_31_0) = 0.5V
.ic V(qb_1_0_0) = 0.5V
.ic V(qb_1_1_0) = 0.5V
.ic V(qb_1_2_0) = 0V
.ic V(qb_1_3_0) = 0.5V
.ic V(qb_1_4_0) = 0V
.ic V(qb_1_5_0) = 0.5V
.ic V(qb_1_6_0) = 0.5V
.ic V(qb_1_7_0) = 0V
.ic V(qb_1_8_0) = 0V
.ic V(qb_1_9_0) = 0V
.ic V(qb_1_10_0) = 0V
.ic V(qb_1_11_0) = 0.5V
.ic V(qb_1_12_0) = 0.5V
.ic V(qb_1_13_0) = 0.5V
.ic V(qb_1_14_0) = 0.5V
.ic V(qb_1_15_0) = 0.5V
.ic V(qb_1_16_0) = 0V
.ic V(qb_1_17_0) = 0.5V
.ic V(qb_1_18_0) = 0V
.ic V(qb_1_19_0) = 0.5V
.ic V(qb_1_20_0) = 0V
.ic V(qb_1_21_0) = 0.5V
.ic V(qb_1_22_0) = 0V
.ic V(qb_1_23_0) = 0V
.ic V(qb_1_24_0) = 0.5V
.ic V(qb_1_25_0) = 0.5V
.ic V(qb_1_26_0) = 0V
.ic V(qb_1_27_0) = 0V
.ic V(qb_1_28_0) = 0V
.ic V(qb_1_29_0) = 0V
.ic V(qb_1_30_0) = 0.5V
.ic V(qb_1_31_0) = 0V
.ic V(qb_2_0_0) = 0V
.ic V(qb_2_1_0) = 0V
.ic V(qb_2_2_0) = 0V
.ic V(qb_2_3_0) = 0V
.ic V(qb_2_4_0) = 0.5V
.ic V(qb_2_5_0) = 0.5V
.ic V(qb_2_6_0) = 0V
.ic V(qb_2_7_0) = 0V
.ic V(qb_2_8_0) = 0.5V
.ic V(qb_2_9_0) = 0.5V
.ic V(qb_2_10_0) = 0.5V
.ic V(qb_2_11_0) = 0V
.ic V(qb_2_12_0) = 0V
.ic V(qb_2_13_0) = 0V
.ic V(qb_2_14_0) = 0V
.ic V(qb_2_15_0) = 0V
.ic V(qb_2_16_0) = 0V
.ic V(qb_2_17_0) = 0.5V
.ic V(qb_2_18_0) = 0V
.ic V(qb_2_19_0) = 0.5V
.ic V(qb_2_20_0) = 0.5V
.ic V(qb_2_21_0) = 0.5V
.ic V(qb_2_22_0) = 0.5V
.ic V(qb_2_23_0) = 0.5V
.ic V(qb_2_24_0) = 0.5V
.ic V(qb_2_25_0) = 0V
.ic V(qb_2_26_0) = 0.5V
.ic V(qb_2_27_0) = 0V
.ic V(qb_2_28_0) = 0.5V
.ic V(qb_2_29_0) = 0V
.ic V(qb_2_30_0) = 0V
.ic V(qb_2_31_0) = 0V
.ic V(qb_3_0_0) = 0.5V
.ic V(qb_3_1_0) = 0V
.ic V(qb_3_2_0) = 0.5V
.ic V(qb_3_3_0) = 0V
.ic V(qb_3_4_0) = 0.5V
.ic V(qb_3_5_0) = 0.5V
.ic V(qb_3_6_0) = 0.5V
.ic V(qb_3_7_0) = 0.5V
.ic V(qb_3_8_0) = 0.5V
.ic V(qb_3_9_0) = 0.5V
.ic V(qb_3_10_0) = 0.5V
.ic V(qb_3_11_0) = 0V
.ic V(qb_3_12_0) = 0.5V
.ic V(qb_3_13_0) = 0.5V
.ic V(qb_3_14_0) = 0.5V
.ic V(qb_3_15_0) = 0.5V
.ic V(qb_3_16_0) = 0.5V
.ic V(qb_3_17_0) = 0V
.ic V(qb_3_18_0) = 0.5V
.ic V(qb_3_19_0) = 0V
.ic V(qb_3_20_0) = 0.5V
.ic V(qb_3_21_0) = 0V
.ic V(qb_3_22_0) = 0V
.ic V(qb_3_23_0) = 0.5V
.ic V(qb_3_24_0) = 0.5V
.ic V(qb_3_25_0) = 0.5V
.ic V(qb_3_26_0) = 0V
.ic V(qb_3_27_0) = 0.5V
.ic V(qb_3_28_0) = 0.5V
.ic V(qb_3_29_0) = 0V
.ic V(qb_3_30_0) = 0.5V
.ic V(qb_3_31_0) = 0.5V
.ic V(qb_0_0_1) = 0.5V
.ic V(qb_0_1_1) = 0.5V
.ic V(qb_0_2_1) = 0V
.ic V(qb_0_3_1) = 0.5V
.ic V(qb_0_4_1) = 0V
.ic V(qb_0_5_1) = 0V
.ic V(qb_0_6_1) = 0.5V
.ic V(qb_0_7_1) = 0V
.ic V(qb_0_8_1) = 0.5V
.ic V(qb_0_9_1) = 0.5V
.ic V(qb_0_10_1) = 0V
.ic V(qb_0_11_1) = 0.5V
.ic V(qb_0_12_1) = 0V
.ic V(qb_0_13_1) = 0.5V
.ic V(qb_0_14_1) = 0V
.ic V(qb_0_15_1) = 0.5V
.ic V(qb_0_16_1) = 0V
.ic V(qb_0_17_1) = 0V
.ic V(qb_0_18_1) = 0V
.ic V(qb_0_19_1) = 0.5V
.ic V(qb_0_20_1) = 0V
.ic V(qb_0_21_1) = 0V
.ic V(qb_0_22_1) = 0V
.ic V(qb_0_23_1) = 0.5V
.ic V(qb_0_24_1) = 0V
.ic V(qb_0_25_1) = 0V
.ic V(qb_0_26_1) = 0.5V
.ic V(qb_0_27_1) = 0V
.ic V(qb_0_28_1) = 0V
.ic V(qb_0_29_1) = 0.5V
.ic V(qb_0_30_1) = 0V
.ic V(qb_0_31_1) = 0V
.ic V(qb_1_0_1) = 0.5V
.ic V(qb_1_1_1) = 0.5V
.ic V(qb_1_2_1) = 0V
.ic V(qb_1_3_1) = 0.5V
.ic V(qb_1_4_1) = 0V
.ic V(qb_1_5_1) = 0.5V
.ic V(qb_1_6_1) = 0.5V
.ic V(qb_1_7_1) = 0V
.ic V(qb_1_8_1) = 0.5V
.ic V(qb_1_9_1) = 0V
.ic V(qb_1_10_1) = 0V
.ic V(qb_1_11_1) = 0.5V
.ic V(qb_1_12_1) = 0.5V
.ic V(qb_1_13_1) = 0V
.ic V(qb_1_14_1) = 0.5V
.ic V(qb_1_15_1) = 0.5V
.ic V(qb_1_16_1) = 0.5V
.ic V(qb_1_17_1) = 0V
.ic V(qb_1_18_1) = 0V
.ic V(qb_1_19_1) = 0V
.ic V(qb_1_20_1) = 0.5V
.ic V(qb_1_21_1) = 0.5V
.ic V(qb_1_22_1) = 0.5V
.ic V(qb_1_23_1) = 0.5V
.ic V(qb_1_24_1) = 0.5V
.ic V(qb_1_25_1) = 0V
.ic V(qb_1_26_1) = 0.5V
.ic V(qb_1_27_1) = 0V
.ic V(qb_1_28_1) = 0V
.ic V(qb_1_29_1) = 0.5V
.ic V(qb_1_30_1) = 0V
.ic V(qb_1_31_1) = 0V
.ic V(qb_2_0_1) = 0.5V
.ic V(qb_2_1_1) = 0V
.ic V(qb_2_2_1) = 0.5V
.ic V(qb_2_3_1) = 0.5V
.ic V(qb_2_4_1) = 0V
.ic V(qb_2_5_1) = 0.5V
.ic V(qb_2_6_1) = 0.5V
.ic V(qb_2_7_1) = 0V
.ic V(qb_2_8_1) = 0V
.ic V(qb_2_9_1) = 0V
.ic V(qb_2_10_1) = 0.5V
.ic V(qb_2_11_1) = 0V
.ic V(qb_2_12_1) = 0.5V
.ic V(qb_2_13_1) = 0V
.ic V(qb_2_14_1) = 0V
.ic V(qb_2_15_1) = 0V
.ic V(qb_2_16_1) = 0.5V
.ic V(qb_2_17_1) = 0V
.ic V(qb_2_18_1) = 0.5V
.ic V(qb_2_19_1) = 0.5V
.ic V(qb_2_20_1) = 0.5V
.ic V(qb_2_21_1) = 0V
.ic V(qb_2_22_1) = 0V
.ic V(qb_2_23_1) = 0.5V
.ic V(qb_2_24_1) = 0V
.ic V(qb_2_25_1) = 0.5V
.ic V(qb_2_26_1) = 0V
.ic V(qb_2_27_1) = 0V
.ic V(qb_2_28_1) = 0V
.ic V(qb_2_29_1) = 0.5V
.ic V(qb_2_30_1) = 0V
.ic V(qb_2_31_1) = 0V
.ic V(qb_3_0_1) = 0.5V
.ic V(qb_3_1_1) = 0V
.ic V(qb_3_2_1) = 0V
.ic V(qb_3_3_1) = 0V
.ic V(qb_3_4_1) = 0.5V
.ic V(qb_3_5_1) = 0V
.ic V(qb_3_6_1) = 0.5V
.ic V(qb_3_7_1) = 0.5V
.ic V(qb_3_8_1) = 0.5V
.ic V(qb_3_9_1) = 0V
.ic V(qb_3_10_1) = 0.5V
.ic V(qb_3_11_1) = 0V
.ic V(qb_3_12_1) = 0V
.ic V(qb_3_13_1) = 0.5V
.ic V(qb_3_14_1) = 0.5V
.ic V(qb_3_15_1) = 0.5V
.ic V(qb_3_16_1) = 0.5V
.ic V(qb_3_17_1) = 0.5V
.ic V(qb_3_18_1) = 0.5V
.ic V(qb_3_19_1) = 0.5V
.ic V(qb_3_20_1) = 0.5V
.ic V(qb_3_21_1) = 0.5V
.ic V(qb_3_22_1) = 0.5V
.ic V(qb_3_23_1) = 0.5V
.ic V(qb_3_24_1) = 0.5V
.ic V(qb_3_25_1) = 0.5V
.ic V(qb_3_26_1) = 0V
.ic V(qb_3_27_1) = 0.5V
.ic V(qb_3_28_1) = 0V
.ic V(qb_3_29_1) = 0.5V
.ic V(qb_3_30_1) = 0V
.ic V(qb_3_31_1) = 0.5V
.ic V(qb_0_0_2) = 0V
.ic V(qb_0_1_2) = 0V
.ic V(qb_0_2_2) = 0V
.ic V(qb_0_3_2) = 0V
.ic V(qb_0_4_2) = 0.5V
.ic V(qb_0_5_2) = 0.5V
.ic V(qb_0_6_2) = 0V
.ic V(qb_0_7_2) = 0V
.ic V(qb_0_8_2) = 0V
.ic V(qb_0_9_2) = 0.5V
.ic V(qb_0_10_2) = 0.5V
.ic V(qb_0_11_2) = 0.5V
.ic V(qb_0_12_2) = 0V
.ic V(qb_0_13_2) = 0V
.ic V(qb_0_14_2) = 0V
.ic V(qb_0_15_2) = 0V
.ic V(qb_0_16_2) = 0V
.ic V(qb_0_17_2) = 0.5V
.ic V(qb_0_18_2) = 0.5V
.ic V(qb_0_19_2) = 0V
.ic V(qb_0_20_2) = 0.5V
.ic V(qb_0_21_2) = 0.5V
.ic V(qb_0_22_2) = 0.5V
.ic V(qb_0_23_2) = 0V
.ic V(qb_0_24_2) = 0.5V
.ic V(qb_0_25_2) = 0.5V
.ic V(qb_0_26_2) = 0V
.ic V(qb_0_27_2) = 0.5V
.ic V(qb_0_28_2) = 0V
.ic V(qb_0_29_2) = 0V
.ic V(qb_0_30_2) = 0.5V
.ic V(qb_0_31_2) = 0.5V
.ic V(qb_1_0_2) = 0V
.ic V(qb_1_1_2) = 0V
.ic V(qb_1_2_2) = 0V
.ic V(qb_1_3_2) = 0V
.ic V(qb_1_4_2) = 0V
.ic V(qb_1_5_2) = 0.5V
.ic V(qb_1_6_2) = 0V
.ic V(qb_1_7_2) = 0V
.ic V(qb_1_8_2) = 0V
.ic V(qb_1_9_2) = 0.5V
.ic V(qb_1_10_2) = 0V
.ic V(qb_1_11_2) = 0V
.ic V(qb_1_12_2) = 0V
.ic V(qb_1_13_2) = 0.5V
.ic V(qb_1_14_2) = 0.5V
.ic V(qb_1_15_2) = 0.5V
.ic V(qb_1_16_2) = 0.5V
.ic V(qb_1_17_2) = 0V
.ic V(qb_1_18_2) = 0.5V
.ic V(qb_1_19_2) = 0.5V
.ic V(qb_1_20_2) = 0.5V
.ic V(qb_1_21_2) = 0V
.ic V(qb_1_22_2) = 0V
.ic V(qb_1_23_2) = 0V
.ic V(qb_1_24_2) = 0V
.ic V(qb_1_25_2) = 0V
.ic V(qb_1_26_2) = 0.5V
.ic V(qb_1_27_2) = 0.5V
.ic V(qb_1_28_2) = 0V
.ic V(qb_1_29_2) = 0.5V
.ic V(qb_1_30_2) = 0V
.ic V(qb_1_31_2) = 0V
.ic V(qb_2_0_2) = 0V
.ic V(qb_2_1_2) = 0.5V
.ic V(qb_2_2_2) = 0.5V
.ic V(qb_2_3_2) = 0.5V
.ic V(qb_2_4_2) = 0V
.ic V(qb_2_5_2) = 0.5V
.ic V(qb_2_6_2) = 0V
.ic V(qb_2_7_2) = 0V
.ic V(qb_2_8_2) = 0V
.ic V(qb_2_9_2) = 0.5V
.ic V(qb_2_10_2) = 0V
.ic V(qb_2_11_2) = 0.5V
.ic V(qb_2_12_2) = 0.5V
.ic V(qb_2_13_2) = 0.5V
.ic V(qb_2_14_2) = 0V
.ic V(qb_2_15_2) = 0.5V
.ic V(qb_2_16_2) = 0V
.ic V(qb_2_17_2) = 0V
.ic V(qb_2_18_2) = 0.5V
.ic V(qb_2_19_2) = 0V
.ic V(qb_2_20_2) = 0.5V
.ic V(qb_2_21_2) = 0V
.ic V(qb_2_22_2) = 0V
.ic V(qb_2_23_2) = 0V
.ic V(qb_2_24_2) = 0V
.ic V(qb_2_25_2) = 0.5V
.ic V(qb_2_26_2) = 0V
.ic V(qb_2_27_2) = 0.5V
.ic V(qb_2_28_2) = 0.5V
.ic V(qb_2_29_2) = 0.5V
.ic V(qb_2_30_2) = 0V
.ic V(qb_2_31_2) = 0.5V
.ic V(qb_3_0_2) = 0.5V
.ic V(qb_3_1_2) = 0.5V
.ic V(qb_3_2_2) = 0V
.ic V(qb_3_3_2) = 0V
.ic V(qb_3_4_2) = 0V
.ic V(qb_3_5_2) = 0V
.ic V(qb_3_6_2) = 0V
.ic V(qb_3_7_2) = 0.5V
.ic V(qb_3_8_2) = 0.5V
.ic V(qb_3_9_2) = 0.5V
.ic V(qb_3_10_2) = 0V
.ic V(qb_3_11_2) = 0V
.ic V(qb_3_12_2) = 0V
.ic V(qb_3_13_2) = 0.5V
.ic V(qb_3_14_2) = 0.5V
.ic V(qb_3_15_2) = 0V
.ic V(qb_3_16_2) = 0.5V
.ic V(qb_3_17_2) = 0.5V
.ic V(qb_3_18_2) = 0.5V
.ic V(qb_3_19_2) = 0.5V
.ic V(qb_3_20_2) = 0V
.ic V(qb_3_21_2) = 0.5V
.ic V(qb_3_22_2) = 0.5V
.ic V(qb_3_23_2) = 0.5V
.ic V(qb_3_24_2) = 0.5V
.ic V(qb_3_25_2) = 0.5V
.ic V(qb_3_26_2) = 0.5V
.ic V(qb_3_27_2) = 0.5V
.ic V(qb_3_28_2) = 0V
.ic V(qb_3_29_2) = 0V
.ic V(qb_3_30_2) = 0V
.ic V(qb_3_31_2) = 0.5V
.ic V(qb_0_0_3) = 0V
.ic V(qb_0_1_3) = 0.5V
.ic V(qb_0_2_3) = 0V
.ic V(qb_0_3_3) = 0V
.ic V(qb_0_4_3) = 0V
.ic V(qb_0_5_3) = 0V
.ic V(qb_0_6_3) = 0V
.ic V(qb_0_7_3) = 0V
.ic V(qb_0_8_3) = 0.5V
.ic V(qb_0_9_3) = 0.5V
.ic V(qb_0_10_3) = 0V
.ic V(qb_0_11_3) = 0V
.ic V(qb_0_12_3) = 0V
.ic V(qb_0_13_3) = 0V
.ic V(qb_0_14_3) = 0V
.ic V(qb_0_15_3) = 0.5V
.ic V(qb_0_16_3) = 0.5V
.ic V(qb_0_17_3) = 0.5V
.ic V(qb_0_18_3) = 0V
.ic V(qb_0_19_3) = 0.5V
.ic V(qb_0_20_3) = 0.5V
.ic V(qb_0_21_3) = 0.5V
.ic V(qb_0_22_3) = 0V
.ic V(qb_0_23_3) = 0.5V
.ic V(qb_0_24_3) = 0.5V
.ic V(qb_0_25_3) = 0.5V
.ic V(qb_0_26_3) = 0V
.ic V(qb_0_27_3) = 0.5V
.ic V(qb_0_28_3) = 0V
.ic V(qb_0_29_3) = 0.5V
.ic V(qb_0_30_3) = 0.5V
.ic V(qb_0_31_3) = 0.5V
.ic V(qb_1_0_3) = 0V
.ic V(qb_1_1_3) = 0V
.ic V(qb_1_2_3) = 0V
.ic V(qb_1_3_3) = 0.5V
.ic V(qb_1_4_3) = 0V
.ic V(qb_1_5_3) = 0V
.ic V(qb_1_6_3) = 0.5V
.ic V(qb_1_7_3) = 0V
.ic V(qb_1_8_3) = 0.5V
.ic V(qb_1_9_3) = 0.5V
.ic V(qb_1_10_3) = 0.5V
.ic V(qb_1_11_3) = 0V
.ic V(qb_1_12_3) = 0V
.ic V(qb_1_13_3) = 0.5V
.ic V(qb_1_14_3) = 0V
.ic V(qb_1_15_3) = 0.5V
.ic V(qb_1_16_3) = 0V
.ic V(qb_1_17_3) = 0V
.ic V(qb_1_18_3) = 0V
.ic V(qb_1_19_3) = 0V
.ic V(qb_1_20_3) = 0V
.ic V(qb_1_21_3) = 0.5V
.ic V(qb_1_22_3) = 0V
.ic V(qb_1_23_3) = 0.5V
.ic V(qb_1_24_3) = 0.5V
.ic V(qb_1_25_3) = 0.5V
.ic V(qb_1_26_3) = 0V
.ic V(qb_1_27_3) = 0V
.ic V(qb_1_28_3) = 0.5V
.ic V(qb_1_29_3) = 0V
.ic V(qb_1_30_3) = 0V
.ic V(qb_1_31_3) = 0V
.ic V(qb_2_0_3) = 0V
.ic V(qb_2_1_3) = 0V
.ic V(qb_2_2_3) = 0.5V
.ic V(qb_2_3_3) = 0V
.ic V(qb_2_4_3) = 0V
.ic V(qb_2_5_3) = 0V
.ic V(qb_2_6_3) = 0V
.ic V(qb_2_7_3) = 0.5V
.ic V(qb_2_8_3) = 0.5V
.ic V(qb_2_9_3) = 0V
.ic V(qb_2_10_3) = 0V
.ic V(qb_2_11_3) = 0V
.ic V(qb_2_12_3) = 0.5V
.ic V(qb_2_13_3) = 0V
.ic V(qb_2_14_3) = 0V
.ic V(qb_2_15_3) = 0V
.ic V(qb_2_16_3) = 0V
.ic V(qb_2_17_3) = 0.5V
.ic V(qb_2_18_3) = 0V
.ic V(qb_2_19_3) = 0V
.ic V(qb_2_20_3) = 0.5V
.ic V(qb_2_21_3) = 0.5V
.ic V(qb_2_22_3) = 0V
.ic V(qb_2_23_3) = 0.5V
.ic V(qb_2_24_3) = 0V
.ic V(qb_2_25_3) = 0.5V
.ic V(qb_2_26_3) = 0V
.ic V(qb_2_27_3) = 0.5V
.ic V(qb_2_28_3) = 0V
.ic V(qb_2_29_3) = 0.5V
.ic V(qb_2_30_3) = 0V
.ic V(qb_2_31_3) = 0V
.ic V(qb_3_0_3) = 0.5V
.ic V(qb_3_1_3) = 0V
.ic V(qb_3_2_3) = 0.5V
.ic V(qb_3_3_3) = 0.5V
.ic V(qb_3_4_3) = 0.5V
.ic V(qb_3_5_3) = 0.5V
.ic V(qb_3_6_3) = 0.5V
.ic V(qb_3_7_3) = 0.5V
.ic V(qb_3_8_3) = 0V
.ic V(qb_3_9_3) = 0.5V
.ic V(qb_3_10_3) = 0V
.ic V(qb_3_11_3) = 0V
.ic V(qb_3_12_3) = 0V
.ic V(qb_3_13_3) = 0.5V
.ic V(qb_3_14_3) = 0V
.ic V(qb_3_15_3) = 0V
.ic V(qb_3_16_3) = 0V
.ic V(qb_3_17_3) = 0.5V
.ic V(qb_3_18_3) = 0V
.ic V(qb_3_19_3) = 0.5V
.ic V(qb_3_20_3) = 0V
.ic V(qb_3_21_3) = 0V
.ic V(qb_3_22_3) = 0V
.ic V(qb_3_23_3) = 0.5V
.ic V(qb_3_24_3) = 0.5V
.ic V(qb_3_25_3) = 0.5V
.ic V(qb_3_26_3) = 0.5V
.ic V(qb_3_27_3) = 0.5V
.ic V(qb_3_28_3) = 0V
.ic V(qb_3_29_3) = 0.5V
.ic V(qb_3_30_3) = 0.5V
.ic V(qb_3_31_3) = 0.5V
